# IAR project host_suspend_resume_hid_mouse_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54618J512 NXP LPC54618J512ET180
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; CPU_LPC54618; USB_STACK_BM; CPU_LPC54618J512ET180=1; USB_STACK_USE_DEDICATED_RAM=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/LPC54618; ../../../../../../platform/drivers; ../../../../../../platform/drivers/common; ../../../..; ../../../../../../middleware/usb_1.6.3; ../../../../../../middleware/usb_1.6.3/osa; ../../../../../../middleware/usb_1.6.3/include; ../../../../../../middleware/usb_1.6.3/host; ../../../../../../middleware/usb_1.6.3/host/class; ../../../../../../devices/LPC54618/drivers; ../../../../../../devices/LPC54618/utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: host_suspend_resume_hid_mouse_bm.out
  ILINK.IlinkConfigDefines: __usb_use_usbram__=1
  ILINK.IlinkIcfFile: LPC54618J512_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../devices/LPC54618/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_LPC54618; USB_STACK_BM; CPU_LPC54618J512ET180=1; USB_STACK_USE_DEDICATED_RAM=1
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/LPC54618/iar/: startup_LPC54618.s
    ../../../../../../devices/LPC54618/: system_LPC54618.c system_LPC54618.h
  group usb/host
    ../../../../../../middleware/usb_1.6.3/host/: usb_host_ohci.c usb_host_ohci.h usb_host_ip3516hs.c usb_host_ip3516hs.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c
  group usb/host/class
    ../../../../../../middleware/usb_1.6.3/host/class/: usb_host_hid.c usb_host_hid.h usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h
  group usb/include
    ../../../../../../middleware/usb_1.6.3/include/: usb.h usb_misc.h usb_spec.h
  group utility
    ../: usb_timer.h usb_mrt_drv.c usb_io.h usb_lpc_io_drv.c
  group osa
    ../../../../../../middleware/usb_1.6.3/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group drivers
    ../../../../../../devices/LPC54618/drivers/: fsl_gint.h fsl_gint.c fsl_mrt.h fsl_mrt.c fsl_inputmux.h fsl_inputmux.c fsl_inputmux_connections.h fsl_common.h fsl_common.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_gpio.h fsl_gpio.c fsl_iocon.h fsl_clock.h fsl_clock.c fsl_reset.h fsl_reset.c fsl_power.h fsl_power.c fsl_emc.h fsl_emc.c
  group sources
    ../: app.c host_mouse.c host_mouse.h usb_host_config.h
  group utilities
    ../../../../../../devices/LPC54618/utilities/: fsl_debug_console.c fsl_debug_console.h
  group board
    ../: clock_config.c clock_config.h board.c board.h pin_mux.c pin_mux.h
    ../../../../../../devices/LPC54618/drivers/: fsl_iocon.h
