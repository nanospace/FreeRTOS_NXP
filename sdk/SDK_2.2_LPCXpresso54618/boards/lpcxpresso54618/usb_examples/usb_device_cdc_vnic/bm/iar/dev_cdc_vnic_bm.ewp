# IAR project dev_cdc_vnic_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54618J512 NXP LPC54618J512ET180
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; CPU_LPC54618; USB_STACK_BM; CPU_LPC54618J512ET180=1; USB_STACK_USE_DEDICATED_RAM=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/LPC54618; ../../../../../../platform/drivers; ../../../../../../platform/drivers/common; ../../../..; ../../../../../../middleware/usb_1.6.3; ../../../../../../middleware/usb_1.6.3/osa; ../../../../../../middleware/usb_1.6.3/include; ../../../../../../middleware/usb_1.6.3/device; ../../../../../../devices/LPC54618/drivers; ../../../../../../devices/LPC54618/utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: dev_cdc_vnic_bm.out
  ILINK.IlinkConfigDefines: __usb_use_usbram__=1
  ILINK.IlinkIcfFile: LPC54618J512_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../devices/LPC54618/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_LPC54618; USB_STACK_BM; CPU_LPC54618J512ET180=1; USB_STACK_USE_DEDICATED_RAM=1
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/LPC54618/iar/: startup_LPC54618.s
    ../../../../../../devices/LPC54618/: system_LPC54618.c system_LPC54618.h
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb_1.6.3/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/lpcip3511
    ../../../../../../middleware/usb_1.6.3/device/: usb_device_lpcip3511.c usb_device_lpcip3511.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/cdc
    ../: usb_device_cdc_acm.c usb_device_cdc_acm.h
  group usb/device/class/cdc_rndis
    ../: usb_device_cdc_rndis.c usb_device_cdc_rndis.h
  group usb/device/include
    ../../../../../../middleware/usb_1.6.3/device/: usb_device.h
  group usb/include
    ../../../../../../middleware/usb_1.6.3/include/: usb.h usb_misc.h usb_spec.h
  group board
    ../: fsl_phy.h fsl_phy.c clock_config.c clock_config.h board.c board.h pin_mux.c pin_mux.h
    ../../../../../../devices/LPC54618/drivers/: fsl_iocon.h
  group sources
    ../: virtual_nic_enet_adapter.c virtual_nic_enet_adapter.h virtual_nic_enetif.c virtual_nic_enetif.h usb_device_descriptor.c usb_device_descriptor.h virtual_nic.c virtual_nic.h usb_device_config.h
  group drivers
    ../../../../../../devices/LPC54618/drivers/: fsl_enet.h fsl_enet.c fsl_common.h fsl_common.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_gpio.h fsl_gpio.c fsl_iocon.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_emc.h fsl_emc.c
  group osa
    ../../../../../../middleware/usb_1.6.3/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group utilities
    ../../../../../../devices/LPC54618/utilities/: fsl_debug_console.c fsl_debug_console.h
