# Keil uVision project $[project_name].uvprojx, settings and files
target $[project_name] Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC54618J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.3.0-dev3
  cpu: IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cproject_templates.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG CPU_LPC54618J512ET180
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;../../../../../devices/LPC54618;../../../../../platform/drivers;../../../../../platform/drivers/common;../../..;../../../../../devices/LPC54618/drivers;../../../../../devices/LPC54618/utilities
  asm define: CPU_LPC54114J256_M4, DEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC54618J512_flash.scf
  link misc: ../../../../../devices/LPC54618/arm/keil_lib_power.lib 
--remove
  group doc
    ../: readme.txt
  group startup
    ../../../../../devices/LPC54618/arm/: startup_LPC54618.s
    ../../../../../devices/LPC54618/: system_LPC54618.c system_LPC54618.h
  group drivers
    ../../../../../devices/LPC54618/drivers/: fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iocon.h fsl_gpio.h fsl_gpio.c fsl_emc.h fsl_emc.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c
  group utilities
    ../../../../../devices/LPC54618/utilities/: fsl_debug_console.c fsl_debug_console.h
target $[project_name] Release (ARM-ADS)
  device: LPC54618J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.3.0-dev3
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: cproject_templates.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG
  c misc: as above
  c include: as above
  asm define: CPU_LPC54114J256_M4, NDEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC54618J512_flash.scf
  link misc: as above
