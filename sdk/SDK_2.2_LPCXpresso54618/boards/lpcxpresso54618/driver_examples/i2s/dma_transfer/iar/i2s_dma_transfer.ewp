# IAR project i2s_dma_transfer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54618J512 NXP LPC54618J512ET180
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_LPC54618; CPU_LPC54618J512ET180=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/LPC54618; ../../../..; ../..; ..; ../../../../../../platform/utilities/debug_console; ../../../../../../devices/LPC54618/drivers; ../../../../../../devices/LPC54618/utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: i2s_dma_transfer.out
  ILINK.IlinkIcfFile: LPC54618J512_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../devices/LPC54618/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_LPC54618; CPU_LPC54618J512ET180=1
  ICCARM.CCOptLevel: 3
  group doc
    ../: readme.txt
  group startup
    ../../../../../../devices/LPC54618/iar/: startup_LPC54618.s
    ../../../../../../devices/LPC54618/: system_LPC54618.c system_LPC54618.h
  group drivers
    ../../../../../../devices/LPC54618/drivers/: fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iocon.h fsl_gpio.h fsl_gpio.c fsl_emc.h fsl_emc.c fsl_i2c.h fsl_i2c.c fsl_i2s.h fsl_i2s.c fsl_i2s_dma.h fsl_i2s_dma.c fsl_dma.c fsl_dma.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_inputmux.h fsl_inputmux.c fsl_reset.h fsl_reset.c
  group source
    ../: i2s_dma_transfer.c
    ../../: music.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group codec
    ../: fsl_wm8904.h fsl_wm8904.c
  group utilities
    ../../../../../../devices/LPC54618/utilities/: fsl_debug_console.c fsl_debug_console.h
