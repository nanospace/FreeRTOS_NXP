# IAR project enet_txrx_ptp1588_transfer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54618J512 NXP LPC54618J512ET180
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_LPC54618; ENET_PTP1588FEATURE_REQUIRED; CPU_LPC54618J512ET180=1; PRINTF_ADVANCED_ENABLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../platform/components/phylan8720a; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/LPC54618; ../../../..; ..; ../../../../../../devices/LPC54618/drivers; ../../../../../../devices/LPC54618/utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: enet_txrx_ptp1588_transfer.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1
  ILINK.IlinkIcfFile: LPC54618J512_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../devices/LPC54618/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_LPC54618; ENET_PTP1588FEATURE_REQUIRED; CPU_LPC54618J512ET180=1; PRINTF_ADVANCED_ENABLE=1
  ICCARM.CCOptLevel: 3
  group doc
    ../: readme.txt
  group startup
    ../../../../../../devices/LPC54618/iar/: startup_LPC54618.s
    ../../../../../../devices/LPC54618/: system_LPC54618.c system_LPC54618.h
  group drivers
    ../../../../../../devices/LPC54618/drivers/: fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iocon.h fsl_gpio.h fsl_gpio.c fsl_emc.h fsl_emc.c fsl_enet.h fsl_enet.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_inputmux.h fsl_inputmux.c fsl_reset.h fsl_reset.c
  group source
    ../: enet_txrx_ptp1588_transfer.c
  group board
    ../: pin_mux.c pin_mux.h fsl_phy.h fsl_phy.c board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../devices/LPC54618/utilities/: fsl_debug_console.c fsl_debug_console.h
