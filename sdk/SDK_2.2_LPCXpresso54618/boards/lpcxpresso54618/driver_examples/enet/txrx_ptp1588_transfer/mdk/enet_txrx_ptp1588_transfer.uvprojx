# Keil uVision project enet_txrx_ptp1588_transfer.uvprojx, settings and files
target enet_txrx_ptp1588_transfer Debug (ARM-ADS)
  device: LPC54618J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.2.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: enet_txrx_ptp1588_transfer.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_LPC54618, ENET_PTP1588FEATURE_REQUIRED, CPU_LPC54618J512ET180=1, PRINTF_ADVANCED_ENABLE=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../platform/components/phylan8720a;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/LPC54618;../../../..;..;../../../../../../devices/LPC54618/drivers;../../../../../../devices/LPC54618/utilities
  asm define: CPU_LPC54114J256_M4, DEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC54618J512_flash.scf
  link misc: ../../../../../../devices/LPC54618/arm/keil_lib_power.lib 
--remove 
--predefine="-D__ram_vector_table__=1"
  group doc
    ../: readme.txt
  group startup
    ../../../../../../devices/LPC54618/arm/: startup_LPC54618.s
    ../../../../../../devices/LPC54618/: system_LPC54618.c system_LPC54618.h
  group drivers
    ../../../../../../devices/LPC54618/drivers/: fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iocon.h fsl_gpio.h fsl_gpio.c fsl_emc.h fsl_emc.c fsl_enet.h fsl_enet.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_inputmux.h fsl_inputmux.c fsl_reset.h fsl_reset.c
  group source
    ../: enet_txrx_ptp1588_transfer.c
  group board
    ../: pin_mux.c pin_mux.h fsl_phy.h fsl_phy.c board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../devices/LPC54618/utilities/: fsl_debug_console.c fsl_debug_console.h
target enet_txrx_ptp1588_transfer Release (ARM-ADS)
  device: LPC54618J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.2.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: enet_txrx_ptp1588_transfer.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_LPC54618, ENET_PTP1588FEATURE_REQUIRED, CPU_LPC54618J512ET180=1, PRINTF_ADVANCED_ENABLE=1
  c misc: as above
  c include: as above
  asm define: CPU_LPC54114J256_M4, NDEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC54618J512_flash.scf
  link misc: as above
