# IAR project mmccard_fatfs.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54618J512 NXP LPC54618J512ET180
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_LPC54618; CPU_LPC54618J512ET180=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/LPC54618; ../../..; ..; ../../../../../middleware/sdmmc_2.1.2/inc; ../../../../../middleware/sdmmc_2.1.2/src; ../../../../../middleware/sdmmc_2.1.2/port; ../../../../../devices/LPC54618/drivers; ../../../../../middleware/fatfs_0.12b/src/fsl_mmc_disk; ../../../../../devices/LPC54618/utilities; ../../../../../middleware/fatfs_0.12b/src; ../../../../../middleware/fatfs_0.12b/src/option
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: mmccard_fatfs.out
  ILINK.IlinkIcfFile: LPC54618J512_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../devices/LPC54618/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_LPC54618; CPU_LPC54618J512ET180=1
  ICCARM.CCOptLevel: 3
  group doc
    ../: readme.txt
  group startup
    ../../../../../devices/LPC54618/iar/: startup_LPC54618.s
    ../../../../../devices/LPC54618/: system_LPC54618.c system_LPC54618.h
  group drivers
    ../../../../../devices/LPC54618/drivers/: fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iocon.h fsl_gpio.h fsl_gpio.c fsl_emc.h fsl_emc.c fsl_sdif.c fsl_sdif.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_inputmux.h fsl_inputmux.c fsl_reset.h fsl_reset.c
  group sdmmc/src
    ../../../../../middleware/sdmmc_2.1.2/src/: fsl_mmc.c fsl_sdmmc.c
  group sdmmc/port
    ../: fsl_host.c event.c event.h
  group sdmmc/inc
    ../../../../../middleware/sdmmc_2.1.2/inc/: fsl_card.h fsl_host.h fsl_sdmmc.h fsl_specification.h
  group fatfs/fatfs_include
    ../../../../../middleware/fatfs_0.12b/src/fsl_mmc_disk/: fsl_mmc_disk.h
    ../../../../../middleware/fatfs_0.12b/src/: integer.h ff.h diskio.h
  group fatfs/fatfs_source
    ../../../../../middleware/fatfs_0.12b/src/fsl_mmc_disk/: fsl_mmc_disk.c
    ../../../../../middleware/fatfs_0.12b/src/: ff.c diskio.c
  group source
    ../: mmccard_fatfs.c ffconf.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/LPC54618/utilities/: fsl_debug_console.c fsl_debug_console.h
