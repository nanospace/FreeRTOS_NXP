# Keil uVision project cmsis_spi_interrupt_transfer.uvprojx, settings and files
target cmsis_spi_interrupt_transfer Debug (ARM-ADS)
  device: LPC54618J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.2.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: cmsis_spi_interrupt_transfer.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_LPC54618, CPU_LPC54618J512ET180=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/LPC54618;../../../..;../../../lpc_spi/interrupt_transfer;..;../../../../../../CMSIS/Driver/Include;../../../../../../devices/LPC54618/drivers;../../../../../../devices/LPC54618/cmsis_drivers;../../../../../../devices/LPC54618/utilities
  asm define: CPU_LPC54114J256_M4, DEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC54618J512_flash.scf
  link misc: ../../../../../../devices/LPC54618/arm/keil_lib_power.lib 
--remove
  group doc
    ../: readme.txt
  group startup
    ../../../../../../devices/LPC54618/arm/: startup_LPC54618.s
    ../../../../../../devices/LPC54618/: system_LPC54618.c system_LPC54618.h
  group drivers
    ../../../../../../devices/LPC54618/drivers/: fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iocon.h fsl_gpio.h fsl_gpio.c fsl_emc.h fsl_emc.c fsl_dma.c fsl_dma.h fsl_spi.c fsl_spi.h fsl_spi_dma.c fsl_spi_dma.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_inputmux.h fsl_inputmux.c fsl_inputmux_connections.h fsl_reset.h fsl_reset.c
    ../../../../../../devices/LPC54618/cmsis_drivers/: fsl_spi_cmsis.h fsl_spi_cmsis.c
  group source
    ../: cmsis_spi_interrupt_transfer.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../devices/LPC54618/utilities/: fsl_debug_console.c fsl_debug_console.h
target cmsis_spi_interrupt_transfer Release (ARM-ADS)
  device: LPC54618J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.2.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: cmsis_spi_interrupt_transfer.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_LPC54618, CPU_LPC54618J512ET180=1
  c misc: as above
  c include: as above
  asm define: CPU_LPC54114J256_M4, NDEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC54618J512_flash.scf
  link misc: as above
