# Keil uVision project freertos_spi.uvprojx, settings and files
target freertos_spi Debug (ARM-ADS)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.1.0-dev11
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: freertos_spi.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../rtos/freertos_9.0.0/Source/portable/RVDS/ARM_CM4F;../../../../../rtos/freertos_9.0.0/Source/include;../../../../../CMSIS/Include;../../../../../devices;../../../../../devices/LPC54608;../../..;..;../../../../../rtos/freertos_9.0.0/Source;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608/utilities
  asm define: CPU_LPC54114J256_M4, DEBUG,__CC_ARM,KEIL
  asm include: ..;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: LPC54608J512_flash.scf
  link misc: ../../../../../devices/LPC54608/arm/keil_lib_power.lib 
--remove
  group doc
    ../: readme.txt
  group startup
    ../../../../../devices/LPC54608/arm/: startup_LPC54608.s
    ../../../../../devices/LPC54608/: system_LPC54608.c system_LPC54608.h
  group freertos:portable
    ../../../../../rtos/freertos_9.0.0/Source/portable/RVDS/ARM_CM4F/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portmacro.h
  group drivers
    ../../../../../devices/LPC54608/drivers/: fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iocon.h fsl_gpio.h fsl_gpio.c fsl_emc.h fsl_emc.c fsl_spi.c fsl_spi.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_inputmux.h fsl_inputmux.c fsl_reset.h fsl_reset.c
  group drivers-freertos
    ../../../../../devices/LPC54608/drivers/: fsl_spi_freertos.h fsl_spi_freertos.c
  group freertos
    ../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
    ../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
    ../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group source
    ../: FreeRTOSConfig.h freertos_spi.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/LPC54608/utilities/: fsl_debug_console.c fsl_debug_console.h
target freertos_spi Release (ARM-ADS)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.1.0-dev11
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: freertos_spi.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: CPU_LPC54114J256_M4, NDEBUG,__CC_ARM,KEIL
  asm include: ..;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC54608J512_flash.scf
  link misc: as above
