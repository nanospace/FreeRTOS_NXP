# IAR project $[project_name].ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54608J512 NXP LPC54608J512
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_LPC54608J512ET180
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/LPC54608; ../../../../../platform/drivers; ../../../../../platform/drivers/common; ../../..; ../../../../../devices/LPC54608/drivers; ../../../../../devices/LPC54608/utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: cppproject_templates.out
  ILINK.IlinkIcfFile: LPC54608J512_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../devices/LPC54608/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC54608J512ET180 NXP LPC54608J512ET180
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/LPC54608/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_emc.c fsl_emc.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_iocon.h fsl_power.c fsl_power.h fsl_usart.c fsl_usart.h
  group startup
    ../../../../../devices/LPC54608/iar/: startup_LPC54608.s
    ../../../../../devices/LPC54608/: system_LPC54608.c system_LPC54608.h
  group utilities
    ../../../../../devices/LPC54608/utilities/: fsl_debug_console.c fsl_debug_console.h
