# Keil uVision project mmccard_fatfs.uvprojx, settings and files
target mmccard_fatfs Debug (ARM-ADS)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.1.0-dev11
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: mmccard_fatfs.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;../../../../../devices/LPC54608;../../..;..;../../../../../middleware/sdmmc_2.1.2/inc;../../../../../middleware/sdmmc_2.1.2/src;../../../../../middleware/sdmmc_2.1.2/port;../../../../../devices/LPC54608/drivers;../../../../../middleware/fatfs_0.12b/src/fsl_mmc_disk;../../../../../devices/LPC54608/utilities;../../../../../middleware/fatfs_0.12b/src;../../../../../middleware/fatfs_0.12b/src/option
  asm define: CPU_LPC54114J256_M4, DEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: LPC54608J512_flash.scf
  link misc: ../../../../../devices/LPC54608/arm/keil_lib_power.lib 
--remove
  group doc
    ../: readme.txt
  group startup
    ../../../../../devices/LPC54608/arm/: startup_LPC54608.s
    ../../../../../devices/LPC54608/: system_LPC54608.c system_LPC54608.h
  group drivers
    ../../../../../devices/LPC54608/drivers/: fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iocon.h fsl_gpio.h fsl_gpio.c fsl_emc.h fsl_emc.c fsl_sdif.c fsl_sdif.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_inputmux.h fsl_inputmux.c fsl_reset.h fsl_reset.c
  group sdmmc-src
    ../../../../../middleware/sdmmc_2.1.2/src/: fsl_mmc.c fsl_sdmmc.c
  group fatfs-fatfs_include
    ../../../../../middleware/fatfs_0.12b/src/fsl_mmc_disk/: fsl_mmc_disk.h
    ../../../../../middleware/fatfs_0.12b/src/: integer.h ff.h diskio.h
  group fatfs-fatfs_source
    ../../../../../middleware/fatfs_0.12b/src/fsl_mmc_disk/: fsl_mmc_disk.c
    ../../../../../middleware/fatfs_0.12b/src/: ff.c diskio.c
  group source
    ../: mmccard_fatfs.c ffconf.h
  group sdmmc-port
    ../: fsl_host.c event.c event.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/LPC54608/utilities/: fsl_debug_console.c fsl_debug_console.h
  group sdmmc-inc
    ../../../../../middleware/sdmmc_2.1.2/inc/: fsl_card.h fsl_host.h fsl_sdmmc.h fsl_specification.h
target mmccard_fatfs Release (ARM-ADS)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.1.0-dev11
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: mmccard_fatfs.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1
  c misc: as above
  c include: as above
  asm define: CPU_LPC54114J256_M4, NDEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC54608J512_flash.scf
  link misc: as above
