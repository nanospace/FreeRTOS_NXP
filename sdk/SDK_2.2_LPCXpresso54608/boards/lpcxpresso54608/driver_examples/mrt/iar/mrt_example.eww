<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>mrt_example</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>mrt_example</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>mrt_example</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>mrt_example</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/mrt_example.ewp</path>
  </project>
</workspace>
