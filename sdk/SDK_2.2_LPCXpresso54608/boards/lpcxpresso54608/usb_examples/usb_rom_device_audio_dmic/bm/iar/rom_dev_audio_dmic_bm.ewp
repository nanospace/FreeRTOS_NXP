# IAR project rom_dev_audio_dmic_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54608J512ET180 NXP LPC54608J512ET180
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_LPC54608; USB_STACK_BM; CPU_LPC54608J512ET180=1; USB_STACK_USE_DEDICATED_RAM=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../inc; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/LPC54608; ../../../../../../platform/drivers; ../../../../../../platform/drivers/common; ../../../..; ../../../../../../devices/LPC54608/drivers; ../../../../../../devices/LPC54608/utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: rom_dev_audio_dmic_bm.out
  ILINK.IlinkConfigDefines: __usb_use_usbram__=1
  ILINK.IlinkIcfFile: LPC54608J512_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../devices/LPC54608/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_LPC54608; USB_STACK_BM; CPU_LPC54608J512ET180=1; USB_STACK_USE_DEDICATED_RAM=1
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/LPC54608/iar/: startup_LPC54608.s
    ../../../../../../devices/LPC54608/: system_LPC54608.c system_LPC54608.h
  group drivers
    ../../../../../../devices/LPC54608/drivers/: fsl_dmic.c fsl_dmic.h fsl_dma.c fsl_dma.h fsl_dmic_dma.c fsl_dmic_dma.h fsl_common.h fsl_common.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_gpio.h fsl_gpio.c fsl_iocon.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_emc.h fsl_emc.c
  group sources
    ../: audio_desc.c audio_main.c app_usbd_cfg.h audio_usbd.c audio_usbd.h main.c delay.c Power_Tasks.h delay.h
  group sources/inc
    ../inc/: usbd_5460x.h romapi_5460x.h error.h usbd.h usbd_cdcuser.h usbd_dfuuser.h usbd_msc.h iap.h usbd_core.h usbd_hid.h usbd_mscuser.h lpc_types.h usbd_adc.h usbd_desc.h usbd_hiduser.h usbd_rom_api.h usbd_cdc.h usbd_dfu.h usbd_hw.h
  group utilities
    ../../../../../../devices/LPC54608/utilities/: fsl_debug_console.c fsl_debug_console.h
  group board
    ../: clock_config.c clock_config.h board.c board.h pin_mux.c pin_mux.h
    ../../../../../../devices/LPC54608/drivers/: fsl_iocon.h
