# Keil uVision project rom_dev_audio_bm.uvprojx, settings and files
target rom_dev_audio_bm Debug (ARM-ADS)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.1.0-dev11
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: rom_dev_audio_bm.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_LPC54608, USB_STACK_BM, CPU_LPC54608J512ET180=1, USB_STACK_USE_DEDICATED_RAM=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..;../inc;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/LPC54608;../../../../../../platform/drivers;../../../../../../platform/drivers/common;../../../..;../../../../../../devices/LPC54608/drivers;../../../../../../devices/LPC54608/utilities
  asm define: CPU_LPC54114J256_M4, DEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: LPC54608J512_flash.scf
  link misc: ../../../../../../devices/LPC54608/arm/keil_lib_power.lib 
--remove 
--predefine="-D__usb_use_usbram__=1"
  group startup
    ../../../../../../devices/LPC54608/arm/: startup_LPC54608.s
    ../../../../../../devices/LPC54608/: system_LPC54608.c system_LPC54608.h
  group sources-inc
    ../inc/: usbd_5460x.h romapi_5460x.h error.h usbd.h usbd_cdcuser.h usbd_dfuuser.h usbd_msc.h iap.h usbd_core.h usbd_hid.h usbd_mscuser.h lpc_types.h usbd_adc.h usbd_desc.h usbd_hiduser.h usbd_rom_api.h usbd_cdc.h usbd_dfu.h usbd_hw.h
  group drivers
    ../../../../../../devices/LPC54608/drivers/: fsl_i2c.h fsl_i2c.c fsl_i2s.h fsl_i2s.c fsl_common.h fsl_common.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_gpio.h fsl_gpio.c fsl_iocon.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_emc.h fsl_emc.c
  group codec
    ../: fsl_wm8904.h fsl_wm8904.c
  group sources
    ../: Power_Tasks.c audio_codec.c audio_main.c delay.c Power_Tasks.h audio_codec.h audio_usbd.c delay.h i2s_if.c main.c sine_file.c app_usbd_cfg.h audio_desc.c audio_usbd.h i2s_if.h pll_setup.c sine_file.h
  group utilities
    ../../../../../../devices/LPC54608/utilities/: fsl_debug_console.c fsl_debug_console.h
  group board
    ../: clock_config.c clock_config.h board.c board.h pin_mux.c pin_mux.h
    ../../../../../../devices/LPC54608/drivers/: fsl_iocon.h
target rom_dev_audio_bm Release (ARM-ADS)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.1.0-dev11
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: rom_dev_audio_bm.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_LPC54608, USB_STACK_BM, CPU_LPC54608J512ET180=1, USB_STACK_USE_DEDICATED_RAM=1
  c misc: as above
  c include: as above
  asm define: CPU_LPC54114J256_M4, NDEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC54608J512_flash.scf
  link misc: as above
