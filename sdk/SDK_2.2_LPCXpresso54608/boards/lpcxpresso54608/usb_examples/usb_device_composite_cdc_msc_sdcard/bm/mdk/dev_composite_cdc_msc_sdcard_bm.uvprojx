# Keil uVision project dev_composite_cdc_msc_sdcard_bm.uvprojx, settings and files
target dev_composite_cdc_msc_sdcard_bm Debug (ARM-ADS)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.1.0-dev11
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dev_composite_cdc_msc_sdcard_bm.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: _DEBUG=1, CPU_LPC54608, USB_STACK_BM, CPU_LPC54608J512ET180=1, USB_STACK_USE_DEDICATED_RAM=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..;../../../../../../platform/drivers/sdif;../../../../../../platform/drivers/lpc_gpio;../../../../../../middleware/sdmmc_2.1.2/port;../../../../../../middleware/sdmmc_2.1.2/port/sdif;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/LPC54608;../../../../../../platform/drivers;../../../../../../platform/drivers/common;../../../..;../../../../../../middleware/usb_1.7.0;../../../../../../middleware/usb_1.7.0/osa;../../../../../../middleware/usb_1.7.0/include;../../../../../../middleware/usb_1.7.0/device;../../../../../../middleware/sdmmc_2.1.2/inc;../../../../../../middleware/sdmmc_2.1.2/src;../../../../../../devices/LPC54608/drivers;../../../../../../devices/LPC54608/utilities
  asm define: CPU_LPC54114J256_M4, DEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: LPC54608J512_flash.scf
  link misc: ../../../../../../devices/LPC54608/arm/keil_lib_power.lib 
--remove 
--predefine="-D__usb_use_usbram__=1"
  group startup
    ../../../../../../devices/LPC54608/arm/: startup_LPC54608.s
    ../../../../../../devices/LPC54608/: system_LPC54608.c system_LPC54608.h
  group usb-device-source-lpcip3511
    ../../../../../../middleware/usb_1.7.0/device/: usb_device_lpcip3511.c usb_device_lpcip3511.h
  group osa
    ../../../../../../middleware/usb_1.7.0/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group usb-device-source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb_1.7.0/device/: usb_device_dci.c usb_device_dci.h
  group usb-device-class
    ../: usb_device_class.c usb_device_class.h
  group usb-device-class-cdc
    ../: usb_device_cdc_acm.c usb_device_cdc_acm.h
  group usb-device-class-msc
    ../: usb_device_msc.c usb_device_msc.h usb_device_msc_ufi.c usb_device_msc_ufi.h
  group drivers
    ../../../../../../devices/LPC54608/drivers/: fsl_sdif.c fsl_sdif.h fsl_common.h fsl_common.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_gpio.h fsl_gpio.c fsl_iocon.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_emc.h fsl_emc.c
  group sdmmc-src
    ../../../../../../middleware/sdmmc_2.1.2/src/: fsl_sd.c fsl_sdmmc.c
  group sources
    ../: composite.c composite.h disk_sdcard.c disk_sdcard.h usb_device_descriptor.c usb_device_descriptor.h virtual_com.c virtual_com.h usb_device_config.h
  group sdmmc-port
    ../: fsl_host.c event.c event.h
  group utilities
    ../../../../../../devices/LPC54608/utilities/: fsl_debug_console.c fsl_debug_console.h
  group usb-include
    ../../../../../../middleware/usb_1.7.0/include/: usb.h usb_misc.h usb_spec.h
  group usb-device-include
    ../../../../../../middleware/usb_1.7.0/device/: usb_device.h
  group sdmmc-inc
    ../../../../../../middleware/sdmmc_2.1.2/inc/: fsl_card.h fsl_host.h fsl_sdmmc.h fsl_specification.h
  group board
    ../: clock_config.c clock_config.h board.c board.h pin_mux.c pin_mux.h
    ../../../../../../devices/LPC54608/drivers/: fsl_iocon.h
target dev_composite_cdc_msc_sdcard_bm Release (ARM-ADS)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.1.0-dev11
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dev_composite_cdc_msc_sdcard_bm.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: _DEBUG=0, CPU_LPC54608, USB_STACK_BM, CPU_LPC54608J512ET180=1, USB_STACK_USE_DEDICATED_RAM=1
  c misc: as above
  c include: as above
  asm define: CPU_LPC54114J256_M4, NDEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC54608J512_flash.scf
  link misc: as above
