# IAR project dev_composite_hid_audio_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54608J512ET180 NXP LPC54608J512ET180
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; CPU_LPC54608; USB_STACK_BM; CPU_LPC54608J512ET180=1; USB_STACK_USE_DEDICATED_RAM=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/LPC54608; ../../../../../../platform/drivers; ../../../../../../platform/drivers/common; ../../../..; ../../../../../../middleware/usb_1.7.0; ../../../../../../middleware/usb_1.7.0/osa; ../../../../../../middleware/usb_1.7.0/include; ../../../../../../middleware/usb_1.7.0/device; ../../../../../../devices/LPC54608/drivers; ../../../../../../devices/LPC54608/utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: dev_composite_hid_audio_bm.out
  ILINK.IlinkConfigDefines: __usb_use_usbram__=1
  ILINK.IlinkIcfFile: LPC54608J512_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../devices/LPC54608/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_LPC54608; USB_STACK_BM; CPU_LPC54608J512ET180=1; USB_STACK_USE_DEDICATED_RAM=1
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/LPC54608/iar/: startup_LPC54608.s
    ../../../../../../devices/LPC54608/: system_LPC54608.c system_LPC54608.h
  group drivers
    ../../../../../../devices/LPC54608/drivers/: fsl_iocon.h fsl_dmic.c fsl_dmic.h fsl_dma.c fsl_dma.h fsl_dmic_dma.c fsl_dmic_dma.h fsl_common.h fsl_common.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_emc.h fsl_emc.c
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb_1.7.0/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/lpcip3511
    ../../../../../../middleware/usb_1.7.0/device/: usb_device_lpcip3511.c usb_device_lpcip3511.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/audio
    ../: usb_device_audio.c usb_device_audio.h
  group usb/device/class/hid
    ../: usb_device_hid.c usb_device_hid.h
  group usb/device/include
    ../../../../../../middleware/usb_1.7.0/device/: usb_device.h
  group usb/include
    ../../../../../../middleware/usb_1.7.0/include/: usb.h usb_misc.h usb_spec.h
  group osa
    ../../../../../../middleware/usb_1.7.0/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group sources
    ../: audio_data_dmic.c audio_generator.c audio_generator.h composite.c composite.h mouse.c mouse.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h usb_audio_config.h
  group utilities
    ../../../../../../devices/LPC54608/utilities/: fsl_debug_console.c fsl_debug_console.h
  group board
    ../: clock_config.c clock_config.h board.c board.h pin_mux.c pin_mux.h
    ../../../../../../devices/LPC54608/drivers/: fsl_iocon.h
