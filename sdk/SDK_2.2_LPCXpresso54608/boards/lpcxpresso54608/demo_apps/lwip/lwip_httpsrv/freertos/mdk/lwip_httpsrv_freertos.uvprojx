# Keil uVision project lwip_httpsrv_freertos.uvprojx, settings and files
target lwip_httpsrv_freertos Debug (ARM-ADS)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.1.0-dev11
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: lwip_httpsrv_freertos.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, HTTPSRV_CFG_WEBSOCKET_ENABLED=1, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../../rtos/freertos_9.0.0/Source/portable/RVDS/ARM_CM4F;../../../../../../../rtos/freertos_9.0.0/Source/include;../../../../../../../platform/components/phylan8720a;../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../devices/LPC54608;../../../../..;..;../../../../../../../middleware/lwip_2.0.0/src/apps/httpsrv;../../../../../../../middleware/lwip_2.0.0/port;../../../../../../../middleware/lwip_2.0.0/src;../../../../../../../middleware/lwip_2.0.0/src/include;../../../../../../../middleware/lwip_2.0.0/contrib/apps;../../../../../../../rtos/freertos_9.0.0/Source;../../../../../../../devices/LPC54608/drivers;../../../../../../../devices/LPC54608/utilities
  asm define: CPU_LPC54114J256_M4, DEBUG,__CC_ARM,KEIL
  asm include: ..;../../../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: LPC54608J512_flash.scf
  link misc: ../../../../../../../devices/LPC54608/arm/keil_lib_power.lib 
--remove
  group doc
    ../: readme.txt
  group startup
    ../../../../../../../devices/LPC54608/arm/: startup_LPC54608.s
    ../../../../../../../devices/LPC54608/: system_LPC54608.c system_LPC54608.h
  group freertos:portable
    ../../../../../../../rtos/freertos_9.0.0/Source/portable/RVDS/ARM_CM4F/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portmacro.h
  group board
    ../: fsl_phy.h fsl_phy.c pin_mux.c pin_mux.h fsl_phy.h fsl_phy.c board.c board.h clock_config.c clock_config.h
  group drivers
    ../../../../../../../devices/LPC54608/drivers/: fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iocon.h fsl_gpio.h fsl_gpio.c fsl_emc.h fsl_emc.c fsl_clock.h fsl_clock.c fsl_enet.h fsl_enet.c fsl_common.h fsl_common.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c
  group lwip-src-apps-httpsrv
    ../../../../../../../middleware/lwip_2.0.0/src/apps/httpsrv/: httpsrv.c httpsrv.h httpsrv_config.h httpsrv_base64.h httpsrv_base64.c httpsrv_fs.c httpsrv_fs.h httpsrv_fs_data.c httpsrv_port.h httpsrv_prv.h httpsrv_script.h httpsrv_script.c httpsrv_sha1.h httpsrv_sha1.c httpsrv_supp.c httpsrv_supp.h httpsrv_task.c httpsrv_tls.c httpsrv_tls.h httpsrv_utf8.h httpsrv_utf8.c httpsrv_ws.h httpsrv_ws.c httpsrv_ws_api.c httpsrv_ws_prv.h
  group freertos
    ../../../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_3.c
    ../../../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
    ../../../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group source
    ../: lwip_httpsrv_freertos.c FreeRTOSConfig.h
  group utilities
    ../../../../../../../devices/LPC54608/utilities/: fsl_debug_console.c fsl_debug_console.h
  group lwip-port
    ../../../../../../../middleware/lwip_2.0.0/port/: ethernetif.c ethernetif.h lwipopts.h sys_arch.c
  group lwip-port-arch
    ../../../../../../../middleware/lwip_2.0.0/port/arch/: cc.h perf.h sys_arch.h
  group lwip-src-api
    ../../../../../../../middleware/lwip_2.0.0/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-src-core
    ../../../../../../../middleware/lwip_2.0.0/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip-src-core-ipv4
    ../../../../../../../middleware/lwip_2.0.0/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip-src-core-ipv6
    ../../../../../../../middleware/lwip_2.0.0/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip-src-include-lwip
    ../../../../../../../middleware/lwip_2.0.0/src/include/lwip/: api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h igmp.h inet.h inet_chksum.h init.h ip.h ip_addr.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpip.h timeouts.h udp.h
  group lwip-src-include-lwip-priv
    ../../../../../../../middleware/lwip_2.0.0/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h tcp_priv.h tcpip_priv.h
  group lwip-src-include-lwip-prot
    ../../../../../../../middleware/lwip_2.0.0/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h ethernet.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip-src-include-netif
    ../../../../../../../middleware/lwip_2.0.0/src/include/netif/: etharp.h ethernet.h lowpan6.h lowpan6_opts.h slipif.h
    ../../../../../../../middleware/lwip_2.0.0/src/include/netif/ppp/: pppoe.h
  group lwip-src-include-posix
    ../../../../../../../middleware/lwip_2.0.0/src/include/posix/: errno.h netdb.h
  group lwip-src-include-posix-sys
    ../../../../../../../middleware/lwip_2.0.0/src/include/posix/sys/: socket.h
  group lwip-src-netif
    ../../../../../../../middleware/lwip_2.0.0/src/netif/: ethernet.c lowpan6.c slipif.c
  group lwip-src-netif-ppp
    ../../../../../../../middleware/lwip_2.0.0/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lwip-src-include-netif-ppp
    ../../../../../../../middleware/lwip_2.0.0/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip-src-include-netif-ppp-polarssl
    ../../../../../../../middleware/lwip_2.0.0/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
target lwip_httpsrv_freertos Release (ARM-ADS)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.1.0-dev11
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: lwip_httpsrv_freertos.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, HTTPSRV_CFG_WEBSOCKET_ENABLED=1, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: CPU_LPC54114J256_M4, NDEBUG,__CC_ARM,KEIL
  asm include: ..;../../../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC54608J512_flash.scf
  link misc: as above
